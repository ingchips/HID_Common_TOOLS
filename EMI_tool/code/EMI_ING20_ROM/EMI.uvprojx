# Keil uVision project EMI.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: ING2000 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M3") CLOCK(12800000) ELITTLE
  output: EMI +hex
  AfterMake: fromelf.exe --bin -o EMI.bin ./output/EMI.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\src;.\src\IAP_BSP;.\src\IAP;.\src\Ctrl;.\src\common;sdk/bundles/rom/inc;sdk/bundles/rom/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing20;sdk/src/Tools;sdk/src;.\src\BQB_lib
  library: MicroLIB
  memory RVCT4: ROM 0x200e000 size 0x72000
  memory RVCT9: RAM 0x200056a8 size 0x4958
  memory RVCT10: RAM 0x200007e0 size 0x4402
  group APP
    ./src/: main.c profile.c noos_impl.c app_main.c
  group StartUP
    ./src/: startup_ing2000.s
    sdk/bundles/rom/ING208xx/: symdefs.m
  group BSP
    sdk/src/BSP/: eflash.c
  group FWlib
    sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_asdm.c peripheral_dma.c peripheral_i2s.c peripheral_keyscan.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    sdk/src/Tools/: trace.c
  group common
    ./src/common/: crc16.c
  group Ctrl
    ./src/Ctrl/: ctrl.c ctrl_emi.c
  group IAP
    ./src/IAP/: IAP.c IAP_Application.c IAP_Bootloader.c IAP_Transport.c IAP_Flash_WP.c
  group IAP_BSP
    ./src/IAP_BSP/: bsp_usb_hid_iap.c
  group BQB_lib
    ./src/BQB_lib/: EMI_LLE_test.lib
software components: CMSIS:CORE 4.3.0
